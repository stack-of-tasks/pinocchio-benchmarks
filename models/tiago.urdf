Commit message: tiago: add 0 inertia to root link for RBDL

File: models/tiago.urdf (robot description, URDF)
Before this commit: robot tiago, 46 links, 45 joints
Links:
- link base_footprint: mass None -> 0
